## main/Kconfig.projbuild
```kconfig
menu "WiFi"

config WIFI_SSID
    string "WiFi SSID"
    default ""

config WIFI_PASSWORD
    string "WiFi Password"
    default ""

endmenu
```
